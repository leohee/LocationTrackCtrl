# Keil uVision project LocationTrack.uvprojx, settings and files
target LocationTrack (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH578M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LocationTrack +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG=0
  c include: ..\include;..\driver\include;..\driver\cmsis
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group driver
    ../driver/: startup_CH579.s
    ../driver/src/: CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_pwr.c CH57x_spi0.c CH57x_sys.c CH57x_timer0.c CH57x_uart0.c CH57x_uart1.c
  group app
    ../src/: main.c
